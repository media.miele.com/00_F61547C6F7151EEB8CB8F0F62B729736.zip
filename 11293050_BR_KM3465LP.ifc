Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2020-11-26T13:02:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 26 13:02:44 2020 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{79F82292-54A0-4571-9F89-E38CB1FF2E67}\ifc * Database version: 5507 * Database creation date: Thu Nov 26 13:02:43 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 26 13:02:44 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 26 13:02:44 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 26346551_BR_11293050_KM3465LP, 11293050_BR_KM3465LP:26346551_BR_11293050_KM3465LP:211994
In: Level 1
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Cast, z_Miele_Design_CLST, z_Miele_Connection_Gas, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 26346551_BR_11293050_KM3465LP
